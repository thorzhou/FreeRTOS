# Keil uVision project Template_freertos.uvprojx, settings and files
target template (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Template_freertos
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\freertos\include;..\freertos\portable\RVDS\ARM_CM3;..\User
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: main.c
  group Freertos/Source
    ../freertos/: list.c
    ../freertos/include/: list.h
  group Doc
    ../Doc/: Readme.md
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.1
